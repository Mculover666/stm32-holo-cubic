# Keil uVision project stm32-holo-cubic.uvprojx, settings and files
target stm32-holo-cubic (6140000::V6.14::ARMCLANG)
  device: STM32L562RETx STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: stm32-holo-cubic +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L562xx,LV_CONF_INCLUDE_SIMPLE,NDEBUG
  c include: ../Core/Inc;../Drivers/STM32L5xx_HAL_Driver/Inc;../Drivers/STM32L5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L5xx/Include;../Drivers/CMSIS/Include;../Hardware/LCD-SPI;../Components/lvgl;../TencentOS-Tiny/arch/arm/arm-v8m/common/include;../TencentOS-Tiny/arch/arm/arm-v8m/cortex-m33/armcc;../TencentOS-Tiny/kernel/core/include;../TencentOS-Tiny/TOS-CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: stm32l562xe_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32l562xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c icache.c spi.c usart.c stm32l5xx_it.c stm32l5xx_hal_msp.c
  group Drivers/STM32L5xx_HAL_Driver
    ../Drivers/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_icache.c stm32l5xx_hal.c stm32l5xx_hal_i2c.c stm32l5xx_hal_i2c_ex.c stm32l5xx_hal_rcc.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_flash.c stm32l5xx_hal_flash_ex.c stm32l5xx_hal_flash_ramfunc.c stm32l5xx_hal_gpio.c stm32l5xx_hal_dma.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_pwr.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cortex.c stm32l5xx_hal_spi.c stm32l5xx_hal_spi_ex.c stm32l5xx_hal_tim.c stm32l5xx_hal_tim_ex.c stm32l5xx_hal_uart.c stm32l5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l5xx.c
  group Hardware
    ../Hardware/LCD-SPI/: lcd_spi_drv.c
  group Components/lvgl/src
    ../Components/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Components/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Components/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../Components/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Components/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Components/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Components/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Components/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Components/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Components/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Components/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Components/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Components/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Components/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Components/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Components/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Components/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../Components/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../Components/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Components/lvgl/src/extra/others/msg/: lv_msg.c
    ../Components/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Components/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Components/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Components/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Components/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Components/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Components/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Components/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Components/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Components/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Components/lvgl/src/extra/widgets/led/: lv_led.c
    ../Components/lvgl/src/extra/widgets/list/: lv_list.c
    ../Components/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Components/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Components/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Components/lvgl/src/extra/widgets/span/: lv_span.c
    ../Components/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Components/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Components/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Components/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Components/lvgl/src/extra/widgets/win/: lv_win.c
    ../Components/lvgl/src/extra/: lv_extra.c
    ../Components/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Components/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Components/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Components/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Components/lvgl/porting
    ../Components/lvgl/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group Components/lvgl/config
    ../Components/lvgl/: lv_conf.h
  group Components/lvgl/example
    ../Components/lvgl/examples/widgets/label/: lv_example_label_1.c
  group tos/arch
    ../TencentOS-Tiny/arch/arm/arm-v8m/common/: tos_cpu.c tos_fault.c
    ../TencentOS-Tiny/arch/arm/arm-v8m/cortex-m33/armcc/: port_c.c port_s.S
  group tos/kernel
    ../TencentOS-Tiny/kernel/core/: tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_rwlock.c tos_sched.c tos_sem.c tos_stopwatch.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/config
    ../TencentOS-Tiny/TOS-CONFIG/: tos_config.h
software components: CMSIS:CORE 4.3.0
